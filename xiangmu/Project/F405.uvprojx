# Keil uVision project F405.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F405 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER,
  c include: ..\CMSIS;..\Library\src;..\Library\inc;..\Startup;..\User;..\FATFS_V0.08A\src;..\SPI_SD_Card;..\FATFS_V0.08A\src\option
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group LIB
    ../Library/src/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group STARTUP
    ../Startup/: startup_stm32f405xx.s
  group USER
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c
  group FATFS
    ../FATFS_V0.08A/src/: diskio.c ff.c
  group SPI_SD_Card
    ../SPI_SD_Card/: SPI_MSD_Driver.c
